Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 2dce184c-54da-4de0-a91c-800ae8aab741, NumberOfSaves: 35]
File name: Project Number
Time: 2024-01-25T10:44:05+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_2173230_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_round jet diffuser jtgo supply LT_sacs:JTGOO 315, NLRS_57_AIR_UN_round jet diffuser jtgo supply LT_sacs:JTGOO 315:2173230
In: Default
Type - Material: NLRS_57_ral 9010_gen_sacs
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_round jet diffuser jtgo supply LT_sacs; SACS_Base_Index: 4
Type - Constraints - Default Elevation: 0 mm
Type - General - FactorTable: JTGO_Factors; LookupTable: JTGO
Type - Identity Data - Assembly Code: 57.0; Description: Solid Air jet diffuser JTGO (supply); Manufacturer: Solid Air Climate Systems; Model: Jet diffuser; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 19-11-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.01; NLRS_C_niveau ontwikkeling: LOD 400; Type Name: JTGOO 315; URL: https://solid-air.nl/producten/solid-air-jetrooster-jtga/
Type - Visibility - SACS_Show_Symbol: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Systems
Classification: 57.0 Uniformat (Uniformat); Material: NLRS_57_ral 9010_gen_sacs, SACS_Label
Pset_DistributionFlowElementCommon - Reference: JTGOO 315; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_round jet diffuser jtgo supply LT_sacs; Family and Type: NLRS_57_AIR_UN_round jet diffuser jtgo supply LT_sacs: JTGOO 315; Type: JTGOO 315; Type Id: 2173221
Model Properties - Color Option: Standard; Color Option (1-4): 1; Horizontal rotation Jet 1: 0 deg; SACS_Color_Ral: no; SACS_Option_1: Ronde uitvoering voor buis; SACS_Standard_Color: yes; Vertical rotation jet 1: 0 deg
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.286471 m2; NLRS_M_c01_diameter: 315 mm; Size: 315ø; Volume: 0.000348479 m3
Identity Data - Mark: 8649; NLRS_C_description: Solid Air jet diffuser JTGO (supply); NLRS_C_materiaal_kleur: RAL 9010 (standard); NLRS_C_model: JTGOOO 315; SACS_Article_Code: 8300000017; SACS_Gross_Cost: 178; SACS_Price_Date: 1-4-2021
Materials and Finishes - SACS_Color: RAL 9010 (standard); SACS_Face_Color: NLRS_57_ral 9010_gen_sacs
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Cooling_Capacity: 0 W; SACS_Heating_Capacity: 0 W; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 40 Pa; SACS_Primairy_Air_Temperature: -273.15 C; SACS_Room_Temperature: -273.15 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0; SACS_Nominal_Max_Flow: 1000 dm3/s; SACS_Nominal_Min_Flow: 200 dm3/s; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Visibility - SACS_Show_Arrows: yes; SACS_Show_Throw: yes; SACS_Warning_Disabled: no
